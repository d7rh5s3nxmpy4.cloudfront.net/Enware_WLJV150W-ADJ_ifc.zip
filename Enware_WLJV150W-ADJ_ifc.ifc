Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-01-17T17:18:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 17 17:18:32 2023 * Host: DESKTOP-33MVG7M * Database: C:\Users\PC-041\AppData\Local\Temp\a085b734-1a44-4364-9c48-9c8e0ba9238e\cfae69a1-8410-47d1-9902-784f9d7c1912\ifc * Database version: 5507 * Database creation date: Tue Jan 17 17:18:32 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 17 17:18:32 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 17 17:18:32 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: Enware_WLJV150W-ADJ_rfa, Enware_WLJV150W-ADJ_rfa:Enware_WLJV150W-ADJ_rfa:3379
In: Level 1
Type - Pset_BuildingElementProxyCommon - Reference: Enware_WLJV150W-ADJ_rfa
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Enware_WLJV150W-ADJ_rfa
Pset_BuildingElementProxyCommon - sets with these values: 2
